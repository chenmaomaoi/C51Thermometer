# Keil uVision project mainProj.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: mainProj +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Files
    ./: main.c LCD_1602.c IIC.c UART.c
  group Header Files
    ./: LCD_1602.h IIC.h UART.h main.h
  group External Dependencies
    ./: STARTUP.A51 intrins.h REG52.H ASCII.h
