# Keil uVision project mainProj.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: mainProj +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Files
    ./: main.c IIC.c UART.c CRC_8.c SHT_30.c Timer_0.c
  group Header Files
    ./: IIC.h UART.h main.h CRC_8.h SHT_30.h Timer_0.h
  group External Dependencies
    ./: STARTUP.A51 intrins.h REG52.H stdio.h string.h
